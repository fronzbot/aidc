*** Voltage Divider ***
*** NETLIST Description ***
R1 vdd vout 1000
R2 vout 0 1000
VDD vdd 0 5
